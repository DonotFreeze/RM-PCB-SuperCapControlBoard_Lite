# Repository DonotFreeze/RM-PCB-SuperCapControlBoard_Lite

File README.md:

# 超级电容控制板 Lite

> 桂林理工大学 · 群星战队 · RoboMaster 2024 赛季开源工程

基于 **STM32G431CB** 的单半桥双向同步 Buck-Boost 超级电容控制板，用于 RoboMaster 机甲大师赛 2024 赛季高校联盟赛、超级对抗赛以及 2025 赛季高校联盟赛。Lite 版本在**保留上一代半桥功率拓扑**的前提下，对外围芯片重新选型，尽量精简外围电路，希望以较小的成本和体积实现较高的性能，并补充了半桥关键测试点与便于调试的板载资源。

> **完整的硬件设计说明** → [RM2024 超级电容控制板 Lite「硬件篇」 · DonotFreeze 的知识库](https://donotfreeze.github.io/robomaster/supercap-controller-lite-hardware/)

## 主要特性

- **单电感同步半桥**：PMOS 防倒灌 + 半桥 Buck/Boost，与半桥 NMOS 的体二极管方向相反，两者同时截止即可完全断开电容组与母线。
- **100 kHz 开关频率**：STM32G4 的 PWM 抖动模式可将分辨率提升至最高 20 位，100 kHz 下约 27200 个计数值可用（未开启时仅 1700），并使用内部 2.5 V 基准作为 ADC 参考，减小 LDO 精度对采样的影响。
- **完整的采样链路**：母线电流单向高边采样（INA139）、电容组电流双向采样（INA181A2 + 1.65 V 偏置）、母线/电容组电压电阻分压，均经 RC 10 kHz 低通滤波后送入 ADC。
- **温度监控**：半桥附近板载 NTC，电容组温度经 MX1.25 接口外接 NTC，为软件过温保护提供依据。
- **调试友好**：半桥关键测试点、复位/复用按键、拨码开关、两路状态指示灯、SWD 下载口。
- **小体积**：约 60 × 40 mm，配合电容组与裁判系统电源管理模块可塞入装甲板支架之间的位置。

## 硬件规格

| 项目 | 参数 |
| --- | --- |
| 主控 | STM32G431CBT6 |
| 拓扑 | 同步 Buck-Boost 半桥（降压充电 / 升压放电） |
| 开关频率 | 100 kHz（PWM 抖动模式） |
| 半桥 MOS | IRFH7440TRPBF × 2 |
| 防倒灌 PMOS | AGM60P100A |
| 栅极驱动 | EG2181 |
| 电感 | 106-125 磁环 11 匝 ≈ 22 µH（16 A 偏置下约 10.9 µH） |
| 母线电流采样 | 2 mΩ + INA139（单向，量程约 12.5 A） |
| 电容电流采样 | 1 mΩ + INA181A2（双向，+17 A / −33 A） |
| 电压采样 | 电阻分压 + LMV321 跟随器 |
| 温度采样 | 半桥 NTC + 外接电容组 NTC |
| 通信 | CAN |
| 辅助电源 | JW5026 × 2（24 V → 10 V / 4 V）+ RT9193（3.3 V） |
| 保护 | 母线 TVS、电容端口 TVS `SMCJ22A`、辅助电源输入自恢复保险丝 |
| 尺寸 | 约 60 × 40 mm × 1.6 mm |

## 工程结构

```text
├─ SuperCapPowerBoard_Lite.kicad_pro   # KiCad 8.0 工程文件
├─ SuperCapPowerBoard_Lite.kicad_sch   # 主控原理图
├─ SuperCapPowerBoard_Lite.kicad_pcb   # PCB 布局与走线
├─ POWER.kicad_sch                     # 功率级原理图
├─ bom/
│  └─ BOM_LITE_2610.html               # 交互式 BOM（点击可定位元件）
├─ GERBER/
│  └─ GERBER_LITE_2610.zip             # Gerber 与钻孔文件
├─ Images/                             # 文档配图
└─ CHANGELOG.md                        # 版本更新日志
```

## 固件代码

本仓库为**纯硬件工程**，不包含固件源码。固件由以下两个独立仓库提供，与本硬件配套使用：

| 仓库 | 说明 |
| --- | --- |
| [**RM-CODE-SuperCapControlBoard_Lite**](https://github.com/DonotFreeze/RM-CODE-SuperCapControlBoard_Lite) | RM2024 赛季超级电容控制板 Lite 的 **CubeMX 代码初始化工程**，提供 STM32 底层外设的 CubeMX 配置 |
| [**RM-SuperCapCtrlLib**](https://github.com/DonotFreeze/RM-SuperCapCtrlLib) | 参加 RoboMaster 机甲大师赛期间开发的 **C 语言库**，可同时用于超级电容控制板 **Lite 和 Plus**，负责充放电环路控制与对外接口 |

## 物料与打样

- BOM 见 `bom/BOM_LITE_2610.html`，Gerber 生产文件见 `GERBER/GERBER_LITE_2610.zip`，可直接送厂打样。
- **磁环电感需自行采购**：`106-125` 磁环（四线 1.0 mm 并绕 11 匝，初始感量约 22 µH）。
- 电容类元件耐压建议 ≥ 35 V；母线侧元件按电池满电 26 V 以上留足冗余。
- 成本参考 84 RMB/套（2024 年 10 月）。

## 参考资料

设计过程中参考的应用笔记与手册如下，完整的设计思路与参数推导见文首的「硬件篇」：

- 《RM0440 - STM32G4 系列参考手册》（PWM 抖动模式、ADC 相关章节）
- 《AN2834 - 如何在 STM32 微控制器中获得最佳 ADC 精度》
- 《AN5690 - 如何在 STM32 MCU 和 MPU 上使用 VREFBUF 外设》
- 《LAT1076 - STM32G4 Advanced Timer Break 功能详解》
- 《LAT1444 - ADC 采样中的阻抗匹配计算方法》
- 《MOSFET 驱动器与 MOSFET 的匹配设计》
- 《低压非隔离 DCDC 开关稳压器设计》
- 《精密低噪声电源设计 - 理论篇》
- 《热回路究竟是什么？》
- 《如何通过最小化热回路 PCB ESR 和 ESL 来优化开关电源布局》
- 《改进低值分流电阻的焊盘布局，优化高电流检测精度》

## 许可证

本作品采用 [CC-BY-4.0](LICENSE) 许可协议进行授权，欢迎转载，但请务必保留作者署名。

## 相关链接

- [RM2024 超级电容控制板 Lite「硬件篇」](https://donotfreeze.github.io/robomaster/supercap-controller-lite-hardware/)（本工程的设计说明）
- [固件代码 · RM-CODE-SuperCapControlBoard_Lite](https://github.com/DonotFreeze/RM-CODE-SuperCapControlBoard_Lite)（CubeMX 代码初始化工程）
- [固件代码 · RM-SuperCapCtrlLib](https://github.com/DonotFreeze/RM-SuperCapCtrlLib)（Lite / Plus 通用的 C 语言库）
- [RM2025 超级电容控制板 Plus「硬件篇」](https://donotfreeze.github.io/robomaster/supercap-controller-plus-hardware/)
- [RM2024 超级电容模组 Lite「使用手册」](https://donotfreeze.github.io/robomaster/supercap-module-lite-user-manual/)
- [RM24-25 超级电容控制板 Lite & Plus「CubeMX 篇」](https://donotfreeze.github.io/robomaster/supercap-controller-cubemx/)
- [RM24-25 超级电容控制板 Lite & Plus「软件篇」](https://donotfreeze.github.io/robomaster/supercap-controller-software/)
- [RM24-25 超级电容模组 Lite & Plus「维护手册」](https://donotfreeze.github.io/robomaster/supercap-module-maintenance-manual/)
- [RM24-25 超级电容模组 Lite & Plus「答疑篇」](https://donotfreeze.github.io/robomaster/supercap-module-faq/)
- [DonotFreeze 的知识库](https://donotfreeze.github.io/)

## KiCad design SuperCapPowerBoard_Lite.kicad_pcb

Parts:
C1, C6, C11, C18, C19: 4.7uF; C_0603_1608Metric
C2, C5, C7, C8, C9, C10, C12, C13, C14, C15, C16, C17: 100nF; C_0603_1608Metric
C3, C4: 12pF; C_0603_1608Metric
C20: 160pF; C_0603_1608Metric
C21, C22, C23: 4.7nF; C_0603_1608Metric
D1: LED_BLUE; LED_0805_2012Metric
D2: LED_GREEN; LED_0805_2012Metric
J1: GH1.25-2PIN; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J2: IPCP254M05PB08S; PinHeader_1x05_P2.54mm_Vertical_SMD_Pin1Left
J3: GH1.25-4PIN; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J4: MX1.25-2PIN; Molex_PicoBlade_53398-0271_1x02-1MP_P1.25mm_Vertical
R1, R2, R3, R13: 47K; R_0603_1608Metric
R4: 120R; R_0603_1608Metric
R5, R6: 100R; R_0603_1608Metric
R7, R10, R12, R14: 4K7; R_0603_1608Metric
R8, R9: 12K; R_0603_1608Metric
R11: 68K; R_0603_1608Metric
R15: 100K; R_0603_1608Metric
R16, R17, R18: 1K; R_0603_1608Metric
SW1: DSHP01TS; SW_DIP_SPSTx01_Slide_Copal_CHS-01B_W7.62mm_P1.27mm
SW2: TS-1086EV-16; SW_Push_1P1T-MP_NO_TS-1086EV-AR03526
TH1: 100K; R_0603_1608Metric
TP1: TEST_OUT; TestPoint_Pad_D1.5mm
U1: STM32G431CBTx; LQFP-48_7x7mm_P0.5mm
U2: MAX3051EKA+T; SOT-23-8
U3: INA181A2; SOT-23-6
U4: INA139; SOT-23-5
U5, U6: LMV321IDCKR; SOT-353_SC-70-5
Y1: 25M; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C1.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, J2.4, J4.1, R2.2, SW1.1, TH1.1, U1.1 (VBAT), U1.21 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.3 (VDD), U3.6 (V+), U4.5 (V+), U5.5 (V+), U6.5 (V+); also elsewhere on the board
+5V: J2.5; also elsewhere on the board
/1.65V: U1.10 (PA2), U3.5 (REF)
/CAN_RX: U1.33 (PA11), U2.4 (RXD)
/CAN_TX: U1.34 (PA12), U2.1 (TXD)
/I_Bat: C20.2, R15.2, U1.9 (PA1), U4.1
/I_Cap: C23.2, R18.2, U1.16 (PB0)
/LED_CAP: R10.2, U1.30 (PA8)
/LED_CHASSIS: R7.2, U1.29 (PB15)
/RST: C7.2, SW2.2, U1.7 (PG10)
/TIM1_BKIN: U1.25 (PB11), U1.26 (PB12)
/Temp_Cap: J4.2, R9.2, U1.17 (PB1)
/Temp_MOS: C13.1, R8.2, TH1.2, U1.18 (PB2)
/V_Bat: C21.2, R16.2, U1.13 (PA5)
/V_Cap: C22.2, R17.2, U1.14 (PA6)
Cap_CTRL: U1.12 (PA4); also elsewhere on the board
GND: C1.1, C2.1, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.1, C22.1, C23.1, D1.1 (K), D2.1 (K), J1.MP (MountPin), J2.3, J3.MP (MountPin), J4.MP (MountPin), R1.2, R3.2, R8.1, R9.1, R12.1, R14.1, R15.1, SW2.1, SW2.MP, U1.19 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.2 (GND), U2.8 (RS), U3.2 (GND), U4.2 (GND), U5.2 (V-), U6.2 (V-), Y1.2, Y1.4; also elsewhere on the board
HIN: U1.31 (PA9); also elsewhere on the board
I_Cap+: U3.3 (+); also elsewhere on the board
I_Cap-: U3.4 (-); also elsewhere on the board
I_bat+: U4.3 (+); also elsewhere on the board
I_bat-: U4.4 (-); also elsewhere on the board
LIN: U1.28 (PB14); also elsewhere on the board
unnamed: D1.2 (A), R7.1
unnamed: D2.2 (A), R10.1
unnamed: J1.1, J3.4, R4.2, U2.6 (CANL)
unnamed: J1.2, J3.3, R4.1, U2.7 (CANH)
unnamed: J2.1, R6.2
unnamed: J2.2, R5.2
unnamed: R18.1, U3.1
unnamed: R2.1, R3.1, U1.15 (PA7)
unnamed: R1.1, U1.45 (PB8)
unnamed: SW1.2, U1.46 (PB9)
unnamed: TP1.1, U1.27 (PB13)
unnamed: C3.1, U1.5 (PF0), Y1.3
unnamed: C4.1, U1.6 (PF1), Y1.1
unnamed: C2.2, C6.2, U1.20 (VREF+)
unnamed: R11.1, R12.2, U5.1 (+)
unnamed: R16.1, U5.3 (-), U5.4
unnamed: R13.1, R14.2, U6.1 (+)
unnamed: R17.1, U6.3 (-), U6.4
SWCLK: R5.1, U1.38 (PA14)
SWDIO: R6.1, U1.37 (PA13)
Vbat: R11.2; also elsewhere on the board
Vcap: R13.2; also elsewhere on the board

Notes on the sheet:
CAN收发器
INA181有烧毁风险 建议使用Plus版
半桥温度检测热敏电阻
电压检测
G431主控
SWD下载口
电流检测
复位/复用按键
状态指示灯
电容组温度检测热敏电阻

Parts:
C24, C25, C41, C42, C43, C52, C53, C55, C56: 10uF; C_1206_3216Metric
C26, C28, C29, C30, C31, C32, C33, C34, C39, C40, C45, C47, C49, C54: 100nF; C_0603_1608Metric
C27, C35, C36, C44, C57: 10uF; C_0603_1608Metric
C37, C38, C48, C51: 100uF; CP_Radial_D8.0mm_P3.50mm
C46: NC; C_0603_1608Metric
C50: 22nF; C_0603_1608Metric
D3: 1N5819W; D_SOD-123F
D4: SMCJ28A; D_SMC
D5: SMF12A; D_SOD-123F
D6: SMF5.0A; D_SOD-123F
D7: SMCJ22A; D_SMC
F1: 1206L010/60NR; Fuse_1206_3216Metric
H2, H4, H6, H7: M2.5; MountingHole_3.1mm_M2.5
L1, L2: APSWPA252012S220MTF; L_Sunlord_SWPA252012S
L3: 600R@100MHz; L_0805_2012Metric
L4: 22uH; L_106125
Q1: DTC143Z; SOT-23
Q2: AGM60P100A; AO_DFN-8-1EP_5.55x5.2mm_P1.27mm_EP4.12x4.6mm
Q3, Q4: IRFH7440; TDSON-8-1
R19, R20, R30, R31, R32: 47K; R_0603_1608Metric
R21: R002; R_Shunt_2512_6332Metric
R22, R23: 10K; R_0603_1608Metric
R24: 118K; R_0603_1608Metric
R25: 52K3; R_0603_1608Metric
R26, R27: 4K7; R_0603_1608Metric
R28, R29: 0R; R_0603_1608Metric
R33: NC; R_0603_1608Metric
R34: R001; R_Shunt_2512_6332Metric
TP2: Vbat; TestPoint_Pad_D1.5mm
TP3: HO; TestPoint_Pad_D1.5mm
TP4: LO; TestPoint_Pad_D1.5mm
TP5: SW; TestPoint_Pad_D1.5mm
TP6: GND; TestPoint_Pad_D1.5mm
TP7: Vcap; TestPoint_Pad_D1.5mm
U7: EG2181D; SOP-8_3.9x4.9mm_P1.27mm
U8, U9: JW5026; SOT-23-6
U10: RT9193; SOT-23-5
XT1, XT3: XT30U-M; AMASS_XT30U-M_1x02_P5.0mm_Vertical
XT2: XT30U-F; AMASS_XT30U-F_1x02_P5.0mm_Vertical

Connections:
+3V3: C54.1, C57.1, U10.5 (VOUT); also elsewhere on the board
+5V: C34.1, C36.1, L2.2, L3.1, R25.2; also elsewhere on the board
+10V: C27.2, C29.1, C33.1, C35.1, D3.2 (A), L1.2, R24.2, U7.5 (VCC)
Cap_CTRL: Q1.1 (B); also elsewhere on the board
GND: C24.2, C25.2, C26.2, C27.1, C28.2, C29.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.1, C40.1, C41.1, C42.1, C43.1, C44.2, C45.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.1, C53.1, C54.2, C55.1, C56.1, C57.2, D4.2 (A), D6.2 (A), D7.2 (A2), H2.1, H4.1, H6.1, H7.1, Q1.2 (E), Q4.1 (S), Q4.2 (S), Q4.3 (S), R22.2, R23.2, R31.2, R33.1, TP6.1, U7.3 (COM), U8.2 (GND), U9.2 (GND), U10.2 (GND), XT1.1 (-), XT2.1 (-), XT3.1 (-); also elsewhere on the board
HIN: U7.1 (HIN); also elsewhere on the board
HO: R28.1, U7.7 (HO)
I_Cap+: R34.2; also elsewhere on the board
I_Cap-: R34.3; also elsewhere on the board
I_bat+: R21.2; also elsewhere on the board
I_bat-: R21.3; also elsewhere on the board
L0: R29.1, U7.4 (LO)
LIN: U7.2 (LIN); also elsewhere on the board
unnamed: C46.1, R33.2
unnamed: C47.1, C48.1, C49.1, C51.1, C52.2, C53.2, C55.2, C56.2, L4.1, R34.1, TP7.1
unnamed: C32.1, D3.1 (K), U7.8 (VB)
unnamed: D5.2 (A), Q2.4 (G), R26.2, R27.1
unnamed: C37.1, C38.1, C39.2, C40.2, C41.2, C42.2, C43.2, D5.1 (K), Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.5 (D), R27.2
unnamed: C44.1, C45.1, D6.1 (K), L3.2, R32.1, U10.1 (VIN)
unnamed: Q1.3 (C), R26.1
unnamed: Q3.4 (G), R28.2, R30.1, TP3.1
unnamed: Q4.4 (G), R29.2, R31.1, TP4.1
unnamed: C30.1, U8.1 (BST)
unnamed: R19.2, U8.4 (EN)
unnamed: R22.1, R24.1, U8.3 (FB)
unnamed: C30.2, L1.1, U8.6 (SW)
unnamed: C24.1, C25.1, C26.1, C28.1, F1.2, R19.1, R20.1, U8.5 (VIN), U9.5 (VIN)
unnamed: C31.1, U9.1 (BST)
unnamed: R20.2, U9.4 (EN)
unnamed: R23.1, R25.1, U9.3 (FB)
unnamed: C31.2, L2.1, U9.6 (SW)
unnamed: C50.1, U10.4 (BP)
unnamed: R32.2, U10.3 (EN)
SW: C32.2, C46.2, L4.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), R30.2, TP5.1, U7.6 (VS)
Vbat: F1.1, R21.1, TP2.1, XT1.2 (+); also elsewhere on the board
Vcap: D7.1 (A1), R34.4, XT3.2 (+); also elsewhere on the board
Vchassis: D4.1 (K), Q2.5 (D), R21.4, XT2.2 (+)

Notes on the sheet:
机械孔
PMOS关断电路
这里的电容全部使用耐压35V或者以上的
主拓扑
底盘并联支路
辅助电源

Board: 4 copper layers, 60.0 x 40.0 mm, 139 parts (15 on the bottom side), 70 nets.

## Commit log (part)

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2026-03-03 上传2610版本
2026-03-03 添加LICENSE文件
2026-03-04 docs(README): 添加超级电容控制板Lite项目详细文档
2026-03-05 ``` feat(.gitignore): 添加.lck文件到忽略列表
    feat(/docs): 添加参考文件PDF
    fix(README): 更新MOS管型号和相关技术参数
    change(/Images): 将所有图片进行压缩
    ```
